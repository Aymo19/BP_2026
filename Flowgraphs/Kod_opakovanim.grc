options:
  parameters:
    generate_options: qt_gui
    id: Kod_opakovanim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: KodKal_Dekoder_Opak_0
  id: KodKal_Dekoder_Opak
  parameters:
    n: '5'
  states: {}
- name: KodKal_Koder_Opak_0
  id: KodKal_Koder_Opak
  parameters:
    k: '5'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Bez"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.25'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Opak"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.25'
  states: {state: disabled}

connections:
- [KodKal_Dekoder_Opak_0, '0', blocks_char_to_float_0_0, '0']
- [KodKal_Koder_Opak_0, '0', KodKal_Dekoder_Opak_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', KodKal_Koder_Opak_0, '0']
- [blocks_throttle2_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
