options:
  parameters:
    generate_options: qt_gui
    id: Kod_opakovanim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: EbN0_max
  id: variable
  parameters:
    value: '15'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: MODULACIA
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: k
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: ErTools_AWGN_0
  id: ErTools_AWGN
  parameters:
    M: M
    k: k
    n: n
  states: {}
- name: ErTools_AWGN_0_0
  id: ErTools_AWGN
  parameters:
    M: M
    k: '1'
    n: '1'
  states: {}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    M: k
    N: N
  states: {}
- name: ErTools_BER_0_0
  id: ErTools_BER
  parameters:
    M: k
    N: N
  states: {}
- name: ErTools_MC_0
  id: ErTools_MC
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    M: M
    Mod: PSK
    N: N
  states: {}
- name: KodKal_Dekoder_Opak_0
  id: KodKal_Dekoder_Opak
  parameters:
    n: n
  states: {}
- name: KodKal_Koder_Opak_0
  id: KodKal_Koder_Opak
  parameters:
    k: n
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: n
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: n
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MODULACIA
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MODULACIA
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: MODULACIA
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: MODULACIA
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    color1: '"red"'
    color2: '"blue"'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"Simulácia BPSK"'
    label2: '"Simulácia BPSK + Hamming"'
    label3: '"Teoretická BPSK"'
    name: '"BER"'
    nconnections: '3'
    update_time: '0.1'
    vlen: N
    width1: '2'
    width2: '2'
    width3: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: float(EbN0_max - EbN0_min) / float(N-1)
    x_units: '"dB"'
    y_axis_label: '"log Pb"'
    ymax: '0'
    ymin: '-6'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RP
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: BEZ
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: EbN0
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: Index
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Index
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Index
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: RP
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: BEZ
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: EbN0
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: EbN0
  states: {}

connections:
- [ErTools_AWGN_0, '0', blocks_vector_to_stream_0, '0']
- [ErTools_AWGN_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_BER_0_0, '0', blocks_nlog10_ff_0_1, '0']
- [ErTools_MC_0, '0', virtual_sink_2, '0']
- [ErTools_MC_0, '1', virtual_sink_2_0, '0']
- [ErTools_Teoreticka_BER_0, '0', blocks_nlog10_ff_0_0, '0']
- [KodKal_Dekoder_Opak_0, '0', ErTools_BER_0, '2']
- [KodKal_Koder_Opak_0, '0', digital_constellation_encoder_bc_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_stream_to_vector_0_1, '0', qtgui_vector_sink_f_0_0, '2']
- [blocks_stream_to_vector_1, '0', ErTools_AWGN_0, '0']
- [blocks_stream_to_vector_1_0, '0', ErTools_AWGN_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_throttle2_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_vector_to_stream_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_vector_to_stream_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', virtual_sink_1_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', blocks_throttle2_0_0, '0']
- [virtual_source_0, '0', ErTools_BER_0, '0']
- [virtual_source_0_0, '0', ErTools_BER_0_0, '0']
- [virtual_source_1, '0', KodKal_Dekoder_Opak_0, '0']
- [virtual_source_1_0, '0', ErTools_BER_0, '1']
- [virtual_source_1_0_0, '0', KodKal_Koder_Opak_0, '0']
- [virtual_source_1_0_0_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [virtual_source_1_0_1, '0', ErTools_BER_0_0, '1']
- [virtual_source_1_1, '0', ErTools_BER_0_0, '2']
- [virtual_source_2, '0', ErTools_AWGN_0, '1']
- [virtual_source_2_0, '0', ErTools_AWGN_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
