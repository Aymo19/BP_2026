options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: EsN0max
  id: variable
  parameters:
    value: '25.'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '-5.'
  states: {}
- name: M0
  id: variable
  parameters:
    value: len(const0)
  states: {}
- name: MaxCount
  id: variable
  parameters:
    value: int(1e7)
  states: {}
- name: MaxErrors
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: MiconstellationObject0
  id: variable_constellation
  parameters:
    const_points: const0
    precision: '8'
    sym_map: numpy.arange(M0)
    type: bpsk
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const0
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: ErTools_BitErrorRate_0
  id: ErTools_BitErrorRate
  parameters:
    EbN0max: '16'
    EbN0min: '0'
    N: '8'
    Rb: '1'
    fvz: '8'
  states: {state: disabled}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: M0
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_BERTool_0
  id: b_BERTool
  parameters:
    B: '128'
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {state: disabled}
- name: b_BERTool_1
  id: b_BERTool
  parameters:
    B: N_snr
    EsN0max: EsN0min
    EsN0min: EsN0max
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const0
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"BPSK"'
    name: '"BER"'
    showports: 'True'
    vlen: N_snr
    width1: '4'
    x_axis_label: '"Es/N0 [dB]"'
    x_start: EsN0min
    x_step: (EsN0max-EsN0min)/float(N_snr)
    x_units: '"dB"'
    y_axis_label: '"logPe"'
    ymax: '0'
    ymin: '-8'
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Noise
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: Original
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: Original
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: Noise
  states: {}

connections:
- [ErTools_BitErrorRate_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [ErTools_BitErrorRate_0, '1', blocks_stream_to_vector_0, '0']
- [analog_random_source_x_1, '0', blocks_throttle2_0, '0']
- [b_BERTool_1, '0', qtgui_vector_sink_f_0, '0']
- [b_BERTool_1, '1', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle2_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_throttle2_0, '0', vs0_1, '0']
- [digital_chunks_to_symbols_xx_1, '0', ErTools_BitErrorRate_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', b_BERTool_1, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', vs1_0_0, '0']
- [virtual_source_0_0_0_0, '0', ErTools_BitErrorRate_0, '2']
- [virtual_source_0_0_0_0, '0', b_BERTool_1, '2']
- [virtual_source_0_1_0, '0', ErTools_BitErrorRate_0, '1']
- [virtual_source_0_1_0, '0', b_BERTool_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
