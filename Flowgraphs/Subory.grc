options:
  parameters:
    generate_options: qt_gui
    id: Subory
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: EbN0_max
  id: variable
  parameters:
    value: '15'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: Modulacia
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=M, differential=False, mod_code="gray", large_ampls_to_corners=False)
  states: {state: disabled}
- name: Modulacia
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: Modulacia_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {state: disabled}
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: Num_samp
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: ErTools_AWGN_0
  id: ErTools_AWGN
  parameters:
    M: '2'
    k: '1'
    n: '1'
  states: {}
- name: ErTools_AWGN_bez_FEC_0
  id: ErTools_AWGN_bez_FEC
  parameters:
    M: '2'
  states: {state: disabled}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    M: '1'
    N: N
  states: {}
- name: ErTools_MC_0
  id: ErTools_MC
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    M: M
    Mod: PSK
    N: N
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aymo/Downloads/message.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Modulacia
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Modulacia
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    color1: '"red"'
    color2: '"blue"'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"Simulácia BPSK"'
    label2: '"Teoretická BPSK"'
    name: '"BER"'
    nconnections: '2'
    update_time: '0.1'
    vlen: N
    width1: '2'
    width2: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: float(EbN0_max - EbN0_min) / float(N - 1)
    x_units: '"dB"'
    y_axis_label: '"log Pb"'
    ymax: '0'
    ymin: '-6'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AWGN_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: EbN0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AWGN_1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: EbN0
  states: {}

connections:
- [ErTools_AWGN_0, '0', blocks_vector_to_stream_0, '0']
- [ErTools_AWGN_bez_FEC_0, '0', blocks_add_xx_0, '1']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_MC_0, '0', virtual_sink_1, '0']
- [ErTools_MC_0, '1', virtual_sink_0_1, '0']
- [ErTools_Teoreticka_BER_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_1_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_stream_to_vector_1, '0', ErTools_AWGN_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_to_stream_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_bez_FEC_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', ErTools_BER_0, '2']
- [virtual_source_0_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [virtual_source_0_0_1, '0', ErTools_BER_0, '0']
- [virtual_source_0_0_2_0, '0', ErTools_BER_0, '1']
- [virtual_source_1, '0', ErTools_AWGN_0, '1']
- [virtual_source_1, '0', ErTools_AWGN_bez_FEC_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
