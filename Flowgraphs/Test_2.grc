options:
  parameters:
    generate_options: qt_gui
    id: Test_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '0'
    min: '-2'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '5'
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    color1: '"magenta"'
    grid: 'True'
    name: '"Noise AMP"'
    size: '1024'
    type: float
    update_time: '2'
    xmax: '10'
    xmin: '-10'
  states: {}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    color1: '"black"'
    grid: 'True'
    name: '"Signal AMP"'
    size: '1024'
    type: float
    update_time: '2'
    xmax: '2'
    xmin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Signal"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    grid: 'True'
    name: '"Noise"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    grid: 'True'
    name: '"Rx mult"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    grid: 'True'
    name: '"Rx add"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: n(t)
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: x(t)
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: n(t)
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: n(t)
  states: {state: disabled}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: n(t)
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {state: disabled}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_float_to_char_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0_2, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0_3, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_float_to_char_0, '0', blocks_throttle2_1_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle2_1, '0', virtual_sink_1, '0']
- [blocks_throttle2_1_0, '0', virtual_sink_0, '0']
- [blocks_xor_xx_0, '0', blocks_char_to_float_1, '0']
- [virtual_source_0, '0', blocks_char_to_float_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_char_to_float_0_2, '0']
- [virtual_source_0_0_0_0, '0', blocks_xor_xx_0, '1']
- [virtual_source_0_1, '0', blocks_char_to_float_0_1, '0']
- [virtual_source_0_1_0, '0', blocks_xor_xx_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_char_to_float_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
