options:
  parameters:
    author: Homero Ortega Boada
    category: comdiguis
    description: 'Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular la curva de BER (Bit error Rate) o SER (simbol error ratio) para una senal con modulacion digital. Parametros usados: N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la entrante envolvente compleja de la señal modulada. La salida son dos senales: out - es la Curva de BER o SER a graficar;  out_env - que es la saliente envolvente compleja con la adicion de ruido AWGN; out ser que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo bits, luego obtenemos curva de BER, pero si M>2 estamos hablando de curva de SER. '
    generate_options: hb
    id: b_BERTool
    output_language: python
    title: b_BERTool
  states: {}

blocks:
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    N: '128'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '32000'
    type: float
  states: {state: disabled}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '128'
  states: {state: disabled}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: int
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in_Tx
    type: byte
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in_Rx
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '32000'
    type: float
  states: {state: disabled}

connections:
- [ErTools_BER_0, '0', blocks_null_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', pad_sink_0_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [pad_source_0_0, '0', ErTools_BER_0, '0']
- [pad_source_0_0_0, '0', ErTools_BER_0, '1']
- [pad_source_0_0_0_0, '0', ErTools_BER_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
