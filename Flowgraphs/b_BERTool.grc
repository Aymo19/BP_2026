options:
  parameters:
    author: Homero Ortega Boada
    category: comdiguis
    description: 'Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular la curva de BER (Bit error Rate) o SER (simbol error ratio) para una senal con modulacion digital. Parametros usados: N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la entrante envolvente compleja de la señal modulada. La salida son dos senales: out - es la Curva de BER o SER a graficar;  out_env - que es la saliente envolvente compleja con la adicion de ruido AWGN; out ser que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo bits, luego obtenemos curva de BER, pero si M>2 estamos hablando de curva de SER. '
    generate_options: hb
    id: b_BERTool
    output_language: python
    title: b_BERTool
  states: {}

blocks:
- name: B
  id: parameter
  parameters:
    label: B
    value: '128'
  states: {state: disabled}
- name: ErTools_BER_moje_0
  id: ErTools_BER_moje
  parameters:
    N: '128'
  states: {}
- name: ErTools_BER_sync_0
  id: ErTools_BER_sync
  parameters:
    N: '128'
  states: {state: disabled}
- name: EsN0max
  id: parameter
  parameters:
    label: EsN0max
    value: '20'
  states: {}
- name: EsN0min
  id: parameter
  parameters:
    label: EsN0min
    value: '0'
  states: {}
- name: N_snr
  id: parameter
  parameters:
    label: N_snr
    value: '128'
  states: {}
- name: Rs
  id: parameter
  parameters:
    label: Rs
    value: '125'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '8'
    type: int
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_int_1
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: NOTA PARA MEJORAR ESTE BLOQUE. Se proponen las siguientes modificaciones; 1) mejorar el canal para que tenga dos entradas, una para la señal modulada, otra para recibir el monto de ruido requerido (No o Pn o Es/No o SNR) 2) complementar  el e_BERToll  para que asuma el roll de ordenar la SNR requerida. 3) optimizar e_BERToll para que haga promediados más largos y enfatice en los valors SNR que sean más relevantes, evitando con ello recalcular parte de las curvas que van quedando bien definidas y concentrandose donde no están tan definidas.
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: out_env
    type: complex
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: N_snr
  states: {}
- name: pad_sink_0_0_0_1
  id: pad_sink
  parameters:
    label: EsNo
    type: int
  states: {state: disabled}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in_Tx
    type: byte
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in_Rx
    type: byte
  states: {}
- name: tempPY_BER_0
  id: tempPY_BER
  parameters:
    N: '128'
  states: {state: disabled}
- name: tipo_mod
  id: parameter
  parameters:
    label: tipo_mod
    value: '"QPSK"'
  states: {state: disabled}

connections:
- [ErTools_BER_moje_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_BER_sync_0, '0', blocks_nlog10_ff_0, '0']
- [analog_const_source_x_0, '0', ErTools_BER_sync_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0_0_0, '0']
- [blocks_float_to_int_0, '0', ErTools_BER_sync_0, '1']
- [blocks_float_to_int_1, '0', ErTools_BER_sync_0, '2']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', pad_sink_0_0_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_float_to_int_1, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_float_to_int_0, '0']
- [pad_source_0_0, '0', blocks_add_xx_0, '1']
- [pad_source_0_0_0, '0', ErTools_BER_moje_0, '0']
- [pad_source_0_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [pad_source_0_0_0, '0', tempPY_BER_0, '0']
- [pad_source_0_0_0_0, '0', ErTools_BER_moje_0, '1']
- [pad_source_0_0_0_0, '0', blocks_uchar_to_float_0, '0']
- [pad_source_0_0_0_0, '0', tempPY_BER_0, '1']
- [tempPY_BER_0, '0', blocks_nlog10_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
