options:
  parameters:
    author: Homero Ortega Boada
    category: comdiguis
    description: 'Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular la curva de BER (Bit error Rate) o SER (simbol error ratio) para una senal con modulacion digital. Parametros usados: N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la entrante envolvente compleja de la señal modulada. La salida son dos senales: out - es la Curva de BER o SER a graficar;  out_env - que es la saliente envolvente compleja con la adicion de ruido AWGN; out ser que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo bits, luego obtenemos curva de BER, pero si M>2 estamos hablando de curva de SER. '
    generate_options: qt_gui
    id: b_BERTool
    output_language: python
    title: b_BERTool
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ErTools_AWGN_kanal_0
  id: ErTools_AWGN_kanal
  parameters:
    EbN0max: '10'
    EbN0min: '0'
    N: '128'
    R: '1'
    W: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '30'
    min: '-30'
    name: '"Moje AWGN AMP"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Moje AWGN"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Noise Source"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}

connections:
- [ErTools_AWGN_kanal_0, '0', blocks_complex_to_float_0, '0']
- [ErTools_AWGN_kanal_0, '0', qtgui_time_sink_x_0, '0']
- [ErTools_AWGN_kanal_0, '1', blocks_null_sink_0, '0']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0_0, '0']
- [blocks_throttle2_0, '0', ErTools_AWGN_kanal_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
