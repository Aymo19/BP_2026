options:
  parameters:
    author: Homero Ortega Boada
    category: comdiguis
    description: 'Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular la curva de BER (Bit error Rate) o SER (simbol error ratio) para una senal con modulacion digital. Parametros usados: N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la entrante envolvente compleja de la señal modulada. La salida son dos senales: out - es la Curva de BER o SER a graficar;  out_env - que es la saliente envolvente compleja con la adicion de ruido AWGN; out ser que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo bits, luego obtenemos curva de BER, pero si M>2 estamos hablando de curva de SER. '
    generate_options: hb
    id: b_BERTool
    output_language: python
    title: b_BERTool
  states: {}

blocks:
- name: B
  id: parameter
  parameters:
    label: B
    value: '128'
  states: {}
- name: ErTools_BitErrorRate_0
  id: ErTools_BitErrorRate
  parameters:
    EbN0max: EsN0max
    EbN0min: EsN0min
    N: N_snr
    Rb: Rs
    fvz: B
  states: {}
- name: EsN0max
  id: parameter
  parameters:
    label: EsN0max
    value: '20'
  states: {}
- name: EsN0min
  id: parameter
  parameters:
    label: EsN0min
    value: '0'
  states: {}
- name: N_snr
  id: parameter
  parameters:
    label: N_snr
    value: '128'
  states: {}
- name: Rs
  id: parameter
  parameters:
    label: Rs
    value: '125'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: NOTA PARA MEJORAR ESTE BLOQUE. Se proponen las siguientes modificaciones; 1) mejorar el canal para que tenga dos entradas, una para la señal modulada, otra para recibir el monto de ruido requerido (No o Pn o Es/No o SNR) 2) complementar  el e_BERToll  para que asuma el roll de ordenar la SNR requerida. 3) optimizar e_BERToll para que haga promediados más largos y enfatice en los valors SNR que sean más relevantes, evitando con ello recalcular parte de las curvas que van quedando bien definidas y concentrandose donde no están tan definidas.
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: N_snr
  states: {}
- name: pad_sink_0_0_0_1
  id: pad_sink
  parameters:
    label: Out
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in_Tx
    type: byte
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in_Rx
    type: byte
  states: {}
- name: tipo_mod
  id: parameter
  parameters:
    label: tipo_mod
    value: '"QPSK"'
  states: {state: disabled}

connections:
- [ErTools_BitErrorRate_0, '0', pad_sink_0_0_0_1, '0']
- [ErTools_BitErrorRate_0, '1', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', pad_sink_0_0_0_0, '0']
- [pad_source_0_0, '0', ErTools_BitErrorRate_0, '0']
- [pad_source_0_0_0, '0', ErTools_BitErrorRate_0, '1']
- [pad_source_0_0_0_0, '0', ErTools_BitErrorRate_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
