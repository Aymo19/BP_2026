options:
  parameters:
    generate_options: qt_gui
    id: Test_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ErTools_BitErrorRate_0
  id: ErTools_BitErrorRate
  parameters:
    EbN0max: '16'
    EbN0min: '0'
    N: '8'
    Rb: '1'
    fvz: '8'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: int
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: int
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    grid: 'True'
    size: '1024'
    type: float
    xmax: '4'
    xmin: '-4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Signal"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    grid: 'True'
    name: '"Noise"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    grid: 'True'
    name: '"Rx mult"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    grid: 'True'
    name: '"Rx add"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '2'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"OG"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"BER"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"OG BER"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: n(t)
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: x(t)
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: n(t)
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: n(t)
  states: {state: disabled}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: n(t)
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {state: disabled}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {state: disabled}

connections:
- [ErTools_BitErrorRate_0, '0', qtgui_time_sink_x_1, '0']
- [ErTools_BitErrorRate_0, '1', qtgui_histogram_sink_x_0, '0']
- [ErTools_BitErrorRate_0, '1', qtgui_time_sink_x_1_1, '0']
- [ErTools_BitErrorRate_0, '1', qtgui_time_sink_x_1_1_0, '0']
- [analog_noise_source_x_0, '0', blocks_throttle2_1_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_random_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_random_source_x_0, '0', blocks_int_to_float_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_1, '0']
- [analog_sig_source_x_1, '0', ErTools_BitErrorRate_0, '0']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_add_xx_1, '0', blocks_int_to_float_0, '0']
- [blocks_float_to_char_0, '0', ErTools_BitErrorRate_0, '2']
- [blocks_float_to_char_0_0, '0', ErTools_BitErrorRate_0, '1']
- [blocks_int_to_float_0, '0', blocks_float_to_char_0, '0']
- [blocks_int_to_float_0_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle2_1, '0', virtual_sink_1, '0']
- [blocks_throttle2_1_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_0_0_0, '0', blocks_add_xx_0, '1']
- [virtual_source_0_1, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_1_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
