options:
  parameters:
    generate_options: qt_gui
    id: Test_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ErTools_PrintChar_0
  id: ErTools_PrintChar
  parameters: {}
  states: {}
- name: ErTools_PrintInt_0
  id: ErTools_PrintInt
  parameters: {}
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '8'
    samples_per_second: '100'
    type: int
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '8'
    samples_per_second: '100'
    type: byte
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0, '0', ErTools_PrintInt_0, '0']
- [blocks_throttle2_0_0, '0', ErTools_PrintChar_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
