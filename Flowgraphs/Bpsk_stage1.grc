options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bpsk_stage1
    output_language: python
    title: bpsk_stage1
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '128'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: ErTools_AWGN_kanal_0
  id: ErTools_AWGN_kanal
  parameters:
    EbN0max: '10'
    EbN0min: '0'
    N: N
    R: '1'
    W: '1'
  states: {}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    N: N
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Re
    label2: Im
    name: '"AWGN"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '20'
    ymin: '-20'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"logPe"'
    size: '1024'
    srate: samp_rate
    type: float
    ymin: '-30'
    yunit: '"log"'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    average: '0.05'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"BPSK"'
    name: '"BER"'
    showports: 'True'
    vlen: N
    width1: '4'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: (10-0)/float(128)
    x_units: '"dB"'
    y_axis_label: '"logPe"'
    ymax: '0'
    ymin: '-8'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AWGN
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AWGN
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT
  states: {}

connections:
- [ErTools_AWGN_kanal_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_kanal_0, '0', qtgui_time_sink_x_0, '0']
- [ErTools_AWGN_kanal_0, '1', virtual_sink_0_1, '0']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_kanal_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', ErTools_AWGN_kanal_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', ErTools_BER_0, '2']
- [virtual_source_0_0, '0', ErTools_BER_0, '1']
- [virtual_source_0_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [virtual_source_0_0_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0_1, '0', ErTools_BER_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
