options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bpsk_stage1
    output_language: python
    title: bpsk_stage1
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: ErTools_AWGN_kanal_0
  id: ErTools_AWGN_kanal
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    N: '128'
    R: '1'
    W: '1'
  states: {}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    N: '128'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"BER"'
    vlen: '128'
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [ErTools_AWGN_kanal_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_kanal_0, '1', ErTools_BER_0, '0']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_BER_0, '0', blocks_throttle2_1, '0']
- [analog_random_source_x_0, '0', ErTools_BER_0, '1']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_1, '0', blocks_nlog10_ff_0, '0']
- [digital_constellation_decoder_cb_0, '0', ErTools_BER_0, '2']
- [digital_constellation_modulator_0, '0', ErTools_AWGN_kanal_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
