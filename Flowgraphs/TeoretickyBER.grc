options:
  parameters:
    generate_options: qt_gui
    id: TeoretickyBER
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: SNR_max
  id: variable
  parameters:
    value: '20'
  states: {}
- name: SNR_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '2'
    N: N
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    grid: 'True'
    size: '1024'
    type: float
    xmax: '0'
    xmin: '-6'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ymin: '-6'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    name: '"BER"'
    update_time: '0.01'
    vlen: N
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: '0.078125'
    y_axis_label: '"Pb"'
    ymax: '1'
    ymin: '-6'
  states: {}

connections:
- [ErTools_Teoreticka_BER_0, '0', blocks_throttle2_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle2_0, '0', blocks_nlog10_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
