options:
  parameters:
    generate_options: qt_gui
    id: TeoretickyBER
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: SNR_max
  id: variable
  parameters:
    value: '20'
  states: {}
- name: SNR_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '2'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '4'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_0_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '64'
    Mod: QAM
    N: N
  states: {state: disabled}
- name: ErTools_Teoreticka_BER_0_1
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '8'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_1_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '128'
    Mod: QAM
    N: N
  states: {state: disabled}
- name: ErTools_Teoreticka_BER_0_2
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '16'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '256'
    Mod: QAM
    N: N
  states: {state: disabled}
- name: ErTools_Teoreticka_BER_0_3
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: SNR_max
    EbN0min: '0'
    M: '16'
    Mod: QAM
    N: N
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_2_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_3
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '100'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    label1: '"Teoreticka BPSK"'
    label2: '"Teoreticka QPSK"'
    label3: '"Teoreticka 8PSK"'
    label4: '"Teoreticka 16PSK"'
    name: '"BER"'
    nconnections: '4'
    update_time: '0.01'
    vlen: N
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: float(SNR_max) / float(N-1)
    y_axis_label: '"log Pb"'
    ymax: '0'
    ymin: '-6'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    label1: '"16-QAM"'
    label2: '"64-QAM"'
    label3: '"128-QAM"'
    label4: '"256-QAM"'
    name: '"BER"'
    nconnections: '4'
    update_time: '0.01'
    vlen: N
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: '0.196850394'
    y_axis_label: '"log Pb"'
    ymax: '0'
    ymin: '-6'
  states: {state: disabled}

connections:
- [ErTools_Teoreticka_BER_0, '0', blocks_throttle2_0, '0']
- [ErTools_Teoreticka_BER_0_0, '0', blocks_throttle2_0_0, '0']
- [ErTools_Teoreticka_BER_0_0_0, '0', blocks_throttle2_0_0_0, '0']
- [ErTools_Teoreticka_BER_0_1, '0', blocks_throttle2_0_1, '0']
- [ErTools_Teoreticka_BER_0_1_0, '0', blocks_throttle2_0_1_0, '0']
- [ErTools_Teoreticka_BER_0_2, '0', blocks_throttle2_0_2, '0']
- [ErTools_Teoreticka_BER_0_2_0, '0', blocks_throttle2_0_2_0, '0']
- [ErTools_Teoreticka_BER_0_3, '0', blocks_throttle2_0_3, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_nlog10_ff_0_2, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_nlog10_ff_0_2_0, '0', blocks_stream_to_vector_0_2_0, '0']
- [blocks_nlog10_ff_0_3, '0', blocks_stream_to_vector_0_3, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_stream_to_vector_0_1, '0', qtgui_vector_sink_f_0, '2']
- [blocks_stream_to_vector_0_1_0, '0', qtgui_vector_sink_f_0_0, '2']
- [blocks_stream_to_vector_0_2, '0', qtgui_vector_sink_f_0, '3']
- [blocks_stream_to_vector_0_2_0, '0', qtgui_vector_sink_f_0_0, '3']
- [blocks_stream_to_vector_0_3, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_throttle2_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_throttle2_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_throttle2_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_throttle2_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_throttle2_0_1_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [blocks_throttle2_0_2, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_throttle2_0_2_0, '0', blocks_nlog10_ff_0_2_0, '0']
- [blocks_throttle2_0_3, '0', blocks_nlog10_ff_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
