options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: variant_b_hamming
    output_language: python
    run_command: '{python} -u {filename} '
    title: MPSK channel with Noise and Hamming Encoding
  states: {}

blocks:
- name: Modulacia
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: modulation
  id: variable_constellation
  parameters:
    const_points: modulation_config.get_constellation(modulation_name)
    precision: '8'
    sym_map: modulation_config.get_symbol_map(modulation_name)
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ErTools_AWGN_0
  id: ErTools_AWGN
  parameters:
    EbN0max: '15'
    EbN0min: '0'
    M: '4'
    N: '256'
  states: {}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    M: '4'
    N: '256'
  states: {state: disabled}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '15'
    EbN0min: '0'
    M: '4'
    Mod: PSK
    N: '256'
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: modulation.bits_per_symbol()
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: modulation.bits_per_symbol()
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: modulation.bits_per_symbol()
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: modulation.bits_per_symbol()
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: '[1] * 4'
    num_outputs: '4'
    type: byte
  states: {}
- name: blocks_stream_demux_1
  id: blocks_stream_demux
  parameters:
    lengths: '[1]*7'
    num_outputs: '7'
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[1]*7'
    num_inputs: '7'
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: '[1]*4'
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '4'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_1_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_1_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Modulacia
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Modulacia
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='(7,4) Hamming encoder',   # will show up in GRC
                  in_sig=[np.int8]*4,
                  out_sig=[np.int8]*7
              )

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              output_items[1][:] = input_items[1]
              output_items[2][:] = input_items[2]
              output_items[3][:] = input_items[3]
              output_items[4][:] = input_items[0] ^ input_items[1] ^ input_items[3]
              output_items[5][:] = input_items[0] ^ input_items[2] ^ input_items[3]
              output_items[6][:] = input_items[1] ^ input_items[2] ^ input_items[3]
              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='(7,4) Hamming decoder',   # will show up in GRC
                  in_sig=[np.int8]*7,
                  out_sig=[np.int8]*4
              )

          def work(self, input_items, output_items):
              syndromes_map = {
                  1: 4,  # p0
                  2: 5,  # p1
                  3: 0,  # c0
                  4: 6,  # p2
                  5: 1,  # c1
                  6: 2,  # c2
                  7: 3   # c3
              }
              syndrome_1 = input_items[0] ^ input_items[1] ^ input_items[3] ^ input_items[4]
              syndrome_2 = input_items[0] ^ input_items[2] ^ input_items[3] ^ input_items[5]
              syndrome_3 = input_items[1] ^ input_items[2] ^ input_items[3] ^ input_items[6]
              syndromes = syndrome_1 + syndrome_2 * 2 + syndrome_3 * 4
              for i, syndrome in enumerate(syndromes):
              	#if syndrome != 0:
              		#input_items[syndromes_map[syndrome]][i] = 1 - input_items[syndromes_map[syndrome]][i]
              	if syndrome == 3:
              		input_items[0][i] = 1 - input_items[0][i]
              	elif syndrome == 5:
              		input_items[1][i] = 1 - input_items[1][i]
              	elif syndrome == 6:
              		input_items[2][i] = 1 - input_items[2][i]
              	elif syndrome == 7:
              		input_items[3][i] = 1 - input_items[3][i]
              	elif syndrome == 1:
              		input_items[4][i] = 1 - input_items[4][i]
              	elif syndrome == 2:
              		input_items[5][i] = 1 - input_items[5][i]
              	elif syndrome == 4:
              		input_items[6][i] = 1 - input_items[6][i]
              output_items[0][:] = input_items[0]
              output_items[1][:] = input_items[1]
              output_items[2][:] = input_items[2]
              output_items[3][:] = input_items[3]
              return len(output_items[0])
  states: {}
- name: modulation_config
  id: epy_module
  parameters:
    source_code: "\r\nimport numpy as np\r\n\r\ndef get_constellation(modulation):\r\n    \"\"\"\r\n    Returns the constellation points for the specified modulation scheme.\r\n\r\n    Parameters:\r\n    modulation (str): The modulation scheme ('BPSK', 'QPSK').\r\n\r\n    Returns:\r\n    numpy.ndarray: Array of constellation points.\r\n    \"\"\"\r\n    modulation = modulation.upper()\r\n\r\n    constellations = {\r\n    'BPSK': lambda: np.array([-1, 1]),\r\n    'QPSK': lambda: np.array([1+1j, 1-1j, -1+1j, -1-1j])\r\n    }\r\n\r\n\r\n    if modulation in constellations:\r\n        return constellations[modulation]()\r\n    else:\r\n        raise ValueError(\"Unsupported modulation type. Use 'BPSK', 'QPSK'.\")\r\n\r\ndef get_symbol_map(modulation):\r\n    \"\"\"\r\n    Returns the symbol map for the specified modulation scheme.\r\n\r\n    Parameters:\r\n    modulation (str): The modulation scheme ('BPSK', 'QPSK').\r\n\r\n    Returns:\r\n    list: A list of symbol indices for the specified modulation scheme.\r\n    \"\"\"\r\n    modulation = modulation.upper()\r\n    symbol_counts = {\r\n        'BPSK': 2,\r\n        'QPSK': 4,\r\n    }\r\n\r\n    if modulation in symbol_counts:\r\n        return [i for i in range(symbol_counts[modulation])]\r\n    else:\r\n        raise ValueError(\"Unsupported modulation type. Use 'BPSK', 'QPSK'.\")\r\n\r\n\r\nimport math\r\n\r\ndef calculate_noise(modulation: str, ebno: float, k: int): \r\n    if modulation == 'BPSK':\r\n        snr_linear = 10 ** (ebno / 10) + 10*math.log(k/7,10)\r\n        noise_variance = 1 / snr_linear \r\n        noise = math.sqrt(noise_variance)\r\n        return noise\r\n\r\n    elif modulation == 'QPSK':\r\n        snr_db = ebno + 10*math.log(2,10) + 10*math.log(k/7,10)\r\n        snr_linear = 10 ** (snr_db / 10)\r\n        noise_variance = 1 / snr_linear \r\n        noise = math.sqrt(noise_variance)\r\n        return noise"
  states: {}
- name: modulation_name
  id: parameter
  parameters:
    label: Modulation Name
    type: str
    value: QPSK
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    size: '1024'
    type: float
    xmax: '6'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    name: '"1"'
    size: '1024'
    type: float
    xmax: '6'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '256'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '5'
    ymax: '2'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    color1: '"red"'
    color2: '"blue"'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"Simulácia HAMMING QPSK"'
    label2: '"Teoreticka GRAY QPSK'
    name: '"BER"'
    nconnections: '2'
    update_time: '0.1'
    vlen: '256'
    width1: '2'
    width2: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: float(15) / float(256 - 1)
    x_units: '"dB"'
    y_axis_label: '"log Pb"'
    ymax: '0'
    ymin: '-6'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: hamming_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: hamming_signal_output
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: hamming_signal
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: hamming_signal_output
  states: {state: disabled}
- name: virtual_source_1_0_2_0
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {state: disabled}

connections:
- [ErTools_AWGN_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_0, '1', ErTools_BER_0, '0']
- [ErTools_AWGN_0, '1', blocks_int_to_float_0, '0']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_Teoreticka_BER_0, '0', blocks_nlog10_ff_0_0, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_2, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_int_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_stream_demux_1, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_null_sink_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_repack_bits_bb_0_1, '0', virtual_sink_1, '0']
- [blocks_stream_demux_0, '0', epy_block_0, '0']
- [blocks_stream_demux_0, '1', epy_block_0, '1']
- [blocks_stream_demux_0, '2', epy_block_0, '2']
- [blocks_stream_demux_0, '3', epy_block_0, '3']
- [blocks_stream_demux_1, '0', epy_block_1, '0']
- [blocks_stream_demux_1, '1', epy_block_1, '1']
- [blocks_stream_demux_1, '2', epy_block_1, '2']
- [blocks_stream_demux_1, '3', epy_block_1, '3']
- [blocks_stream_demux_1, '4', epy_block_1, '4']
- [blocks_stream_demux_1, '5', epy_block_1, '5']
- [blocks_stream_demux_1, '6', epy_block_1, '6']
- [blocks_stream_mux_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_mux_1, '0', blocks_repack_bits_bb_0_1, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0_1_0_0, '0', ErTools_BER_0, '2']
- [blocks_unpacked_to_packed_xx_0_1_1, '0', ErTools_BER_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_null_sink_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '1']
- [epy_block_0, '0', blocks_stream_mux_0, '0']
- [epy_block_0, '1', blocks_stream_mux_0, '1']
- [epy_block_0, '2', blocks_stream_mux_0, '2']
- [epy_block_0, '3', blocks_stream_mux_0, '3']
- [epy_block_0, '4', blocks_stream_mux_0, '4']
- [epy_block_0, '5', blocks_stream_mux_0, '5']
- [epy_block_0, '6', blocks_stream_mux_0, '6']
- [epy_block_1, '0', blocks_stream_mux_1, '0']
- [epy_block_1, '1', blocks_stream_mux_1, '1']
- [epy_block_1, '2', blocks_stream_mux_1, '2']
- [epy_block_1, '3', blocks_stream_mux_1, '3']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1_0_0_0_0, '0', ErTools_BER_0, '1']
- [virtual_source_1_0_0_0_0, '0', blocks_char_to_float_1, '0']
- [virtual_source_1_0_0_0_0, '0', blocks_unpacked_to_packed_xx_0_1_1, '0']
- [virtual_source_1_0_2_0, '0', ErTools_BER_0, '2']
- [virtual_source_1_0_2_0, '0', blocks_char_to_float_1_0, '0']
- [virtual_source_1_0_2_0, '0', blocks_unpacked_to_packed_xx_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
