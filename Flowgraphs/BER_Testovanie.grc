options:
  parameters:
    author: Marek Hetteš
    category: Custom
    description: Hlavny zapojenie pre BP1
    generate_options: qt_gui
    id: BER_Testovanie
    output_language: python
    title: BER Testovanie
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '16'
  states: {}
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: Num_samp
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: OPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {state: disabled}
- name: QAM
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {state: disabled}
- name: QAM_Binary
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=M, differential=False, mod_code="none", large_ampls_to_corners=False)
  states: {}
- name: QAM_Gray
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=M, differential=False, mod_code="gray", large_ampls_to_corners=False)
  states: {}
- name: QPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: SNR_max
  id: variable
  parameters:
    value: '20'
  states: {}
- name: SNR_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: SQAM
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {state: disabled}
- name: Typ_kodu
  id: variable
  parameters:
    value: QAM_Binary
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: ErTools_AWGN_0
  id: ErTools_AWGN
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: M
    N: N
  states: {}
- name: ErTools_AWGN_0_0
  id: ErTools_AWGN
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '2'
    N: N
  states: {state: disabled}
- name: ErTools_AWGN_0_0_0
  id: ErTools_AWGN
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '8'
    N: N
  states: {state: disabled}
- name: ErTools_AWGN_0_0_1
  id: ErTools_AWGN
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '16'
    N: N
  states: {state: disabled}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    M: M
    N: N
  states: {}
- name: ErTools_BER_0_0
  id: ErTools_BER
  parameters:
    M: ''
    N: N
  states: {state: disabled}
- name: ErTools_BER_0_1
  id: ErTools_BER
  parameters:
    M: ''
    N: N
  states: {state: disabled}
- name: ErTools_BER_0_2
  id: ErTools_BER
  parameters:
    M: ''
    N: N
  states: {state: disabled}
- name: ErTools_SER_0
  id: ErTools_SER
  parameters:
    N: N
  states: {state: disabled}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '2'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '4'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_1
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '4'
    Mod: QAM
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '16'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '16'
    Mod: QAM
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2_0_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '32'
    Mod: QAM
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2_0_1
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '64'
    Mod: QAM
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2_0_1_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '128'
    Mod: QAM
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_2_0_1_0_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: '256'
    Mod: QAM
    N: N
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: Num_samp
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_2_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_2_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_2_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_2_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_2_0_1_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_2_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_2_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_2_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_2_0_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Typ_kodu
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: OPSK
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: SQAM
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Typ_kodu
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: QPSK
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: OPSK
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0_0_1
  id: digital_constellation_encoder_bc
  parameters:
    constellation: SQAM
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    autoscale: 'False'
    bins: '1024'
    grid: 'True'
    size: '1024'
    type: float
    xmax: '20'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    color1: '"magenta"'
    color10: '"red"'
    color3: '"blue"'
    color4: '"green"'
    color5: '"black"'
    color6: '"yellow"'
    color7: '"dark blue"'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"Realna 16QAM"'
    label10: '"Teoreticka 256QAM"'
    label2: '"Teoreticka BPSK"'
    label3: '"Teoreticka QPSK"'
    label4: '"Teoreticka 4QAM"'
    label5: '"Teoreticka 16PSK"'
    label6: '"Teoreticka 16QAM"'
    label7: '"Teoreticka 32QAM"'
    label8: '"Teoreticka 64QAM"'
    label9: '"Teoreticka 128QAM"'
    name: '"BER"'
    nconnections: '10'
    update_time: '0.1'
    vlen: N
    width1: '2'
    width10: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    width5: '2'
    width6: '2'
    width7: '2'
    width8: '2'
    width9: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: '0.078125'
    x_units: '"dB"'
    y_axis_label: '"log Pb"'
    ymax: '1'
    ymin: '-6'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AWGN_B
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT_B
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT_Q
  states: {state: disabled}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT_O
  states: {state: disabled}
- name: virtual_sink_0_1_0_1
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT_S
  states: {state: disabled}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: AWGN_Q
  states: {state: disabled}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: AWGN_O
  states: {state: disabled}
- name: virtual_sink_0_2_1
  id: virtual_sink
  parameters:
    stream_id: AWGN_S
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AWGN_B
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {state: disabled}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {state: disabled}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT_B
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT_Q
  states: {state: disabled}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT_O
  states: {state: disabled}
- name: virtual_source_0_0_1_2
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT_S
  states: {state: disabled}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {state: disabled}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {state: disabled}
- name: virtual_source_0_0_4
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: AWGN_Q
  states: {state: disabled}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: AWGN_O
  states: {state: disabled}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: AWGN_S
  states: {state: disabled}

connections:
- [ErTools_AWGN_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_0, '1', virtual_sink_0_1, '0']
- [ErTools_AWGN_0_0, '0', blocks_add_xx_0_0, '1']
- [ErTools_AWGN_0_0, '1', virtual_sink_0_1_0, '0']
- [ErTools_AWGN_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [ErTools_AWGN_0_0_0, '1', virtual_sink_0_1_0_0, '0']
- [ErTools_AWGN_0_0_1, '0', blocks_add_xx_0_0_1, '1']
- [ErTools_AWGN_0_0_1, '1', virtual_sink_0_1_0_1, '0']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_BER_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [ErTools_BER_0_1, '0', blocks_nlog10_ff_0_2, '0']
- [ErTools_BER_0_2, '0', blocks_nlog10_ff_0_3, '0']
- [ErTools_SER_0, '0', blocks_nlog10_ff_0_1, '0']
- [ErTools_Teoreticka_BER_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [ErTools_Teoreticka_BER_0_0, '0', blocks_nlog10_ff_0_1_0_0, '0']
- [ErTools_Teoreticka_BER_0_1, '0', blocks_nlog10_ff_0_1_0_1, '0']
- [ErTools_Teoreticka_BER_0_2, '0', blocks_nlog10_ff_0_1_0_2, '0']
- [ErTools_Teoreticka_BER_0_2_0, '0', blocks_nlog10_ff_0_1_0_2_0, '0']
- [ErTools_Teoreticka_BER_0_2_0_0, '0', blocks_nlog10_ff_0_1_0_2_0_0, '0']
- [ErTools_Teoreticka_BER_0_2_0_1, '0', blocks_nlog10_ff_0_1_0_2_0_1, '0']
- [ErTools_Teoreticka_BER_0_2_0_1_0, '0', blocks_nlog10_ff_0_1_0_2_0_1_0, '0']
- [ErTools_Teoreticka_BER_0_2_0_1_0_0, '0', blocks_nlog10_ff_0_1_0_2_0_1_0_0, '0']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_add_xx_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_add_xx_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_add_xx_0_0_1, '0', digital_constellation_decoder_cb_0_0_1, '0']
- [blocks_char_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_nlog10_ff_0_1_0_0, '0', blocks_stream_to_vector_0_1_0_0, '0']
- [blocks_nlog10_ff_0_1_0_1, '0', blocks_stream_to_vector_0_1_0_1, '0']
- [blocks_nlog10_ff_0_1_0_2, '0', blocks_stream_to_vector_0_1_0_2, '0']
- [blocks_nlog10_ff_0_1_0_2_0, '0', blocks_stream_to_vector_0_1_0_2_0, '0']
- [blocks_nlog10_ff_0_1_0_2_0_0, '0', blocks_stream_to_vector_0_1_0_2_0_0, '0']
- [blocks_nlog10_ff_0_1_0_2_0_1, '0', blocks_stream_to_vector_0_1_0_2_0_1, '0']
- [blocks_nlog10_ff_0_1_0_2_0_1_0, '0', blocks_stream_to_vector_0_1_0_2_0_1_0, '0']
- [blocks_nlog10_ff_0_1_0_2_0_1_0_0, '0', blocks_stream_to_vector_0_1_0_2_0_1_0_0, '0']
- [blocks_nlog10_ff_0_2, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_nlog10_ff_0_3, '0', blocks_stream_to_vector_0_3, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_1_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_stream_to_vector_0_1_0_0, '0', qtgui_vector_sink_f_0_0, '2']
- [blocks_stream_to_vector_0_1_0_1, '0', qtgui_vector_sink_f_0_0, '3']
- [blocks_stream_to_vector_0_1_0_2, '0', qtgui_vector_sink_f_0_0, '4']
- [blocks_stream_to_vector_0_1_0_2_0, '0', qtgui_vector_sink_f_0_0, '5']
- [blocks_stream_to_vector_0_1_0_2_0_0, '0', qtgui_vector_sink_f_0_0, '6']
- [blocks_stream_to_vector_0_1_0_2_0_1, '0', qtgui_vector_sink_f_0_0, '7']
- [blocks_stream_to_vector_0_1_0_2_0_1_0, '0', qtgui_vector_sink_f_0_0, '8']
- [blocks_stream_to_vector_0_1_0_2_0_1_0_0, '0', qtgui_vector_sink_f_0_0, '9']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_throttle2_0_0_1, '0', blocks_add_xx_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', ErTools_BER_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', ErTools_BER_0_1, '0']
- [blocks_unpack_k_bits_bb_0_2, '0', ErTools_BER_0_2, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', virtual_sink_0_2, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', virtual_sink_0_2_0, '0']
- [digital_constellation_decoder_cb_0_0_1, '0', virtual_sink_0_2_1, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', ErTools_AWGN_0_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_encoder_bc_0_0_0, '0', ErTools_AWGN_0_0_0, '0']
- [digital_constellation_encoder_bc_0_0_0, '0', blocks_throttle2_0_0_0, '0']
- [digital_constellation_encoder_bc_0_0_1, '0', ErTools_AWGN_0_0_1, '0']
- [digital_constellation_encoder_bc_0_0_1, '0', blocks_throttle2_0_0_1, '0']
- [virtual_source_0, '0', ErTools_BER_0, '2']
- [virtual_source_0, '0', ErTools_SER_0, '0']
- [virtual_source_0_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [virtual_source_0_0_0_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', digital_constellation_encoder_bc_0_0_0, '0']
- [virtual_source_0_0_0_0_1, '0', digital_constellation_encoder_bc_0_0_1, '0']
- [virtual_source_0_0_1, '0', ErTools_BER_0, '0']
- [virtual_source_0_0_1, '0', ErTools_SER_0, '1']
- [virtual_source_0_0_1_0, '0', ErTools_BER_0_0, '1']
- [virtual_source_0_0_1_1, '0', ErTools_BER_0_1, '1']
- [virtual_source_0_0_1_2, '0', ErTools_BER_0_2, '1']
- [virtual_source_0_0_2, '0', ErTools_BER_0_0, '2']
- [virtual_source_0_0_2_0, '0', ErTools_BER_0, '1']
- [virtual_source_0_0_2_0, '0', ErTools_SER_0, '2']
- [virtual_source_0_0_3, '0', ErTools_BER_0_1, '2']
- [virtual_source_0_0_4, '0', ErTools_BER_0_2, '2']
- [virtual_source_0_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_0_2, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [virtual_source_0_3, '0', blocks_unpack_k_bits_bb_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
