options:
  parameters:
    author: Marek Hetteš
    category: Custom
    description: Hlavny zapojenie pre BP1
    generate_options: qt_gui
    id: BER_Testovanie
    output_language: python
    title: BER Testovanie
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Modulacia
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: Num_samp
  id: variable
  parameters:
    value: '500'
  states: {}
- name: SNR_max
  id: variable
  parameters:
    value: '20'
  states: {}
- name: SNR_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: ErTools_AWGN_0
  id: ErTools_AWGN
  parameters:
    EbN0max: '20'
    EbN0min: '0'
    M: M
    N: N
  states: {}
- name: ErTools_AWGN_kanal_0
  id: ErTools_AWGN_kanal
  parameters:
    EbN0max: SNR_max
    EbN0min: SNR_min
    N: N
  states: {state: disabled}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    N: N
  states: {}
- name: ErTools_SER_0
  id: ErTools_SER
  parameters:
    N: N
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: Num_samp
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Modulacia
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Modulacia
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    grid: 'True'
    name: '"Stare"'
    size: '1024'
    type: float
    xmax: '2'
    xmin: '-2'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1024'
    grid: 'True'
    name: '"Nove"'
    size: '1024'
    type: float
    xmax: '2'
    xmin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Stare - EbN0"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Nove - EsN0"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    gui_hint: 2,0,1,1
    label1: '"BER"'
    label2: '"SER"'
    name: '"BER"'
    nconnections: '2'
    vlen: N
    width1: '2'
    width2: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: '0.078125'
    x_units: '"dB"'
    y_axis_label: '"log Pe"'
    ymax: '1'
    ymin: '-6'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    average: '0.05'
    gui_hint: 2,0,1,1
    label1: '"BPSK"'
    name: '"BER"'
    vlen: N
    width1: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: '0.078125'
    x_units: '"dB"'
    y_axis_label: '"log Pe"'
    ymax: '1'
    ymin: '-6'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AWGN
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AWGN
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT
  states: {}

connections:
- [ErTools_AWGN_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_0, '0', blocks_complex_to_float_0_0, '0']
- [ErTools_AWGN_0, '0', qtgui_time_sink_x_0_0, '0']
- [ErTools_AWGN_0, '1', blocks_null_sink_0, '0']
- [ErTools_AWGN_0, '1', virtual_sink_0_1, '0']
- [ErTools_AWGN_kanal_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_kanal_0, '0', blocks_complex_to_float_0, '0']
- [ErTools_AWGN_kanal_0, '0', qtgui_time_sink_x_0, '0']
- [ErTools_AWGN_kanal_0, '1', virtual_sink_0_1, '0']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_SER_0, '0', blocks_nlog10_ff_0_1, '0']
- [analog_const_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_const_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_add_xx_1, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_null_sink_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_null_sink_0_1, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', ErTools_BER_0, '2']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_0, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_kanal_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', ErTools_SER_0, '2']
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_0_0, '0', ErTools_BER_0, '1']
- [virtual_source_0_0, '0', ErTools_SER_0, '1']
- [virtual_source_0_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [virtual_source_0_0_1, '0', ErTools_BER_0, '0']
- [virtual_source_0_0_1, '0', ErTools_SER_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
