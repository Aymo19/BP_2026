options:
  parameters:
    author: Marek Hetteš
    category: Custom
    description: Hlavny zapojenie pre BP1
    generate_options: qt_gui
    id: BER_Testovanie
    output_language: python
    title: BER Testovanie
  states: {}

blocks:
- name: EbN0_max
  id: variable
  parameters:
    value: '15'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: Modulacia
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: Modulacia
  id: variable
  parameters:
    value: QAM_Gray
  states: {state: disabled}
- name: Modulacia_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: N
  id: variable
  parameters:
    value: '256'
  states: {}
- name: Num_samp
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: QAM_Binary
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=16, differential=False, mod_code="none", large_ampls_to_corners=False)
  states: {state: disabled}
- name: QAM_Gray
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=16, differential=False, mod_code="gray", large_ampls_to_corners=False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: ErTools_AWGN_0
  id: ErTools_AWGN
  parameters:
    M: M
    k: '1'
    n: '1'
  states: {}
- name: ErTools_AWGN_0_0
  id: ErTools_AWGN
  parameters:
    M: '8'
    k: '1'
    n: '1'
  states: {}
- name: ErTools_AWGN_0_0_0
  id: ErTools_AWGN
  parameters:
    M: '16'
    k: '1'
    n: '1'
  states: {}
- name: ErTools_BER_0
  id: ErTools_BER
  parameters:
    M: M
    N: N
  states: {}
- name: ErTools_BER_0_0
  id: ErTools_BER
  parameters:
    M: '8'
    N: N
  states: {}
- name: ErTools_BER_0_0_0
  id: ErTools_BER
  parameters:
    M: '16'
    N: N
  states: {}
- name: ErTools_MC_0
  id: ErTools_MC
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    M: M
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_0
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    M: '8'
    Mod: PSK
    N: N
  states: {}
- name: ErTools_Teoreticka_BER_0_1
  id: ErTools_Teoreticka_BER
  parameters:
    EbN0max: EbN0_max
    EbN0min: EbN0_min
    M: '16'
    Mod: QAM
    N: N
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: Num_samp
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '8'
    min: '0'
    num_samps: Num_samp
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '16'
    min: '0'
    num_samps: Num_samp
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Modulacia
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: Modulacia_0
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QAM_Gray
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Modulacia
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: Modulacia_0
  states: {}
- name: digital_constellation_encoder_bc_0_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: QAM_Gray
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: encoder_variable
    itype: byte
    otype: byte
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    color1: '"red"'
    color2: '"blue"'
    color4: '"cyan"'
    color5: '"black"'
    color6: '"yellow"'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '"Simulácia BPSK"'
    label2: '"Simulácia 8PSK"'
    label3: '"Simulácia 16-QAM"'
    label4: '"Teoreticka BPSK"'
    label5: '"Teoreticka 8PSK"'
    label6: '"Teoreticka 16-QAM"'
    name: '"BER"'
    nconnections: '6'
    update_time: '0.1'
    vlen: N
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    width5: '2'
    width6: '2'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: '0'
    x_step: float(EbN0_max - EbN0_min) / float(N - 1)
    x_units: '"dB"'
    y_axis_label: '"log Pb"'
    ymax: '0'
    ymin: '-6'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AWGN_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: AWGN_2
  states: {}
- name: virtual_sink_0_3
  id: virtual_sink
  parameters:
    stream_id: AWGN_3
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: EbN0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AWGN_1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: AWGN_3
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: SAMP_POINT
  states: {}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: SIGNAL
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: AWGN_2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: EbN0
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: EbN0
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: EbN0
  states: {}

connections:
- [ErTools_AWGN_0, '0', blocks_add_xx_0, '1']
- [ErTools_AWGN_0_0, '0', blocks_add_xx_0_0, '1']
- [ErTools_AWGN_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [ErTools_BER_0, '0', blocks_nlog10_ff_0, '0']
- [ErTools_BER_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [ErTools_BER_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [ErTools_MC_0, '0', virtual_sink_1, '0']
- [ErTools_MC_0, '1', virtual_sink_0_1, '0']
- [ErTools_Teoreticka_BER_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [ErTools_Teoreticka_BER_0_0, '0', blocks_nlog10_ff_0_1_0_0, '0']
- [ErTools_Teoreticka_BER_0_1, '0', blocks_nlog10_ff_0_1_0_1, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [analog_random_source_x_0_0, '0', ErTools_BER_0_0, '1']
- [analog_random_source_x_0_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [analog_random_source_x_0_0_0, '0', ErTools_BER_0_0_0, '1']
- [analog_random_source_x_0_0_0, '0', digital_constellation_encoder_bc_0_0_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_add_xx_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_add_xx_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_nlog10_ff_0_1_0_0, '0', blocks_stream_to_vector_0_1_0_0, '0']
- [blocks_nlog10_ff_0_1_0_1, '0', blocks_stream_to_vector_0_1_0_1, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', qtgui_vector_sink_f_0_0, '2']
- [blocks_stream_to_vector_0_1_0, '0', qtgui_vector_sink_f_0_0, '3']
- [blocks_stream_to_vector_0_1_0_0, '0', qtgui_vector_sink_f_0_0, '4']
- [blocks_stream_to_vector_0_1_0_1, '0', qtgui_vector_sink_f_0_0, '5']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', virtual_sink_0_2, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', virtual_sink_0_3, '0']
- [digital_constellation_encoder_bc_0, '0', ErTools_AWGN_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', ErTools_AWGN_0_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_encoder_bc_0_0_0, '0', ErTools_AWGN_0_0_0, '0']
- [digital_constellation_encoder_bc_0_0_0, '0', blocks_throttle2_0_0_0, '0']
- [virtual_source_0, '0', ErTools_BER_0, '2']
- [virtual_source_0_0, '0', ErTools_BER_0_0_0, '2']
- [virtual_source_0_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [virtual_source_0_0_1, '0', ErTools_BER_0, '0']
- [virtual_source_0_0_1_0, '0', ErTools_BER_0_0_0, '0']
- [virtual_source_0_0_1_1, '0', ErTools_BER_0_0, '0']
- [virtual_source_0_0_2_0, '0', ErTools_BER_0, '1']
- [virtual_source_0_1, '0', ErTools_BER_0_0, '2']
- [virtual_source_1, '0', ErTools_AWGN_0, '1']
- [virtual_source_1_0, '0', ErTools_AWGN_0_0, '1']
- [virtual_source_1_0_0, '0', ErTools_AWGN_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
